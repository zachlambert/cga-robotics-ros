Commit message: More tidying up

File: model/delta/materials.urdf.xacro (robot description, xacro)
@@ -10,5 +10,5 @@
     <color rgba="0 1 0 1"/>
 </material>
-<material name="end_effector">
+<material name="ee">
     <color rgba="1 0 1 1"/>
 </material>
